# Keil uVision project dpp.uvprojx, settings and files
target FreeRTOS_port (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: TM4C123GH6PM Texas Instruments
  pack: Keil.TM4C_DFP.1.1.0
  cpu: IROM(0x00000000,0x040000) IRAM(0x20000000,0x008000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: dpp
  BeforeMake: cmd /c "del .\dbg\qstamp.o"
  AfterMake: fromelf --bin --output .\dbg\dpp.bin .\dbg\dpp.axf
  c flags: Optim=1 OneElfS=1 uC99=1 wLevel=2
  c define: __FPU_PRESENT
  c include: ..\..\FreeRtos_proj;..\..\qpc\include;..\..\qpc\src;..\..\qpc\ports\freertos;..\FreeRTOS\Source\include;..\FreeRTOS\Source\portable\RVDS\ARM_CM4F;..\CMSIS\Include;..\ek-tm4c123gxl
  asm define: Stack_Size=1024 Heap_Size=16
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  link misc: --entry Reset_Handler
  group ek-tm4c123gxl
    C:/Users/Itai/Documents/Embedded_New/QM_projects/keil_V/FreeRtos_proj/ek-tm4c123gxl/: system_TM4C123GH6PM.c TM4C123GH6PM.h startup_TM4C123GH6PM.s gpio.h rom.h sysctl.h system_TM4C123GH6PM.h
  group QP
    C:/Users/Itai/Documents/Embedded_New/QM_projects/keil_V/qpc/src/qf/: qep_hsm.c qep_msm.c qf_act.c qf_actq.c qf_defer.c qf_dyn.c qf_mem.c qf_ps.c qf_qact.c qf_qeq.c qf_qmact.c qf_time.c
  group QP_port
    C:/Users/Itai/Documents/Embedded_New/QM_projects/keil_V/qpc/ports/freertos/: qf_port.c
  group QS
    C:/Users/Itai/Documents/Embedded_New/QM_projects/keil_V/qpc/src/qs/: qs.c qs_64bit.c qs_fp.c qs_rx.c
  group FreeRTOS
    C:/Users/Itai/Documents/Embedded_New/QM_projects/keil_V/FreeRtos_proj/FreeRTOS/Source/: list.c tasks.c
    C:/Users/Itai/Documents/Embedded_New/QM_projects/keil_V/FreeRtos_proj/FreeRTOS/Source/portable/RVDS/ARM_CM4F/: port.c portmacro.h
target dpp-rel (5060020::V5.06 (build 20)::ARMCC)
  device: TM4C123GH6PM Texas Instruments
  pack: Keil.TM4C_DFP.1.1.0
  cpu: as above
  output: dpp
  BeforeMake: cmd /c "del .\rel\qstamp.o"
  AfterMake: fromelf --bin --output .\rel\dpp.bin .\rel\dpp.axf
  c flags: Optim=4 OneElfS=1 wLevel=2
  c define: NDEBUG __FPU_PRESENT
  c include: ..;..\..\..\..\..\include;..\..\..\..\..\src;..\..\..\..\..\ports\freertos;..\..\..\..\..\3rd_party\FreeRTOS\Source\include;..\..\..\..\..\3rd_party\FreeRTOS\Source\portable\RVDS\ARM_CM4F;..\..\..\..\..\3rd_party\CMSIS\Include;..\..\..\..\..\3rd_party\ek-tm4c123gxl
  asm define: Stack_Size=1024 Heap_Size=16
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  link misc: --entry Reset_Handler
target dpp-spy (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: TM4C123GH6PM Texas Instruments
  pack: Keil.TM4C_DFP.1.1.0
  cpu: as above
  output: dpp
  BeforeMake: cmd /c "del .\spy\qstamp.o"
  AfterMake: fromelf --bin --output .\spy\dpp.bin .\spy\dpp.axf
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: Q_SPY __FPU_PRESENT
  c include: as above
  asm define: Stack_Size=1024 Heap_Size=16
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  link misc: --entry Reset_Handler
